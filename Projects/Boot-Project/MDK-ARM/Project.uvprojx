# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F032x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.21
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ba_fan_boot +hex
  AfterMake: fromelf --bincombined --output="..\..\Output\ba_fan_boot.bin" ".\Output\ba_fan_boot.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F032x8,USE_FULL_LL_DRIVER,BOOT_PROJECT,POWER_CTRL_GPIO
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\PY32F032\Include;..\..\..\Drivers\PY32F032_HAL_Driver\Inc;..\..\..\Bsp\Inc;..\..\..\Middleware\common\timer_base;..\..\..\Middleware\common\aip650e;..\..\..\Middleware\common\param;..\..\..\Middleware\common\port;..\..\..\Middleware\common\bootloader;..\..\..\Middleware\protocol;..\..\..\Middleware\protocol\generic_protocol;..\..\..\Middleware\data_structure;..\..\..\Middleware\algorithm;..\..\..\Application
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./: startup_py32f032xx.s
    ../Src/: system_py32f032.c
  group Drivers/PY32F032_HAL_Driver
    ../../../Drivers/PY32F032_HAL_Driver/Src/: py32f032_ll_utils.c py32f032_ll_adc.c py32f032_ll_comp.c py32f032_ll_crc.c py32f032_ll_dma.c py32f032_ll_exti.c py32f032_ll_gpio.c py32f032_ll_i2c.c py32f032_ll_lptim.c py32f032_ll_lpuart.c py32f032_ll_pwr.c py32f032_ll_rcc.c py32f032_ll_rtc.c py32f032_ll_spi.c py32f032_ll_tim.c py32f032_ll_uart.c py32f032_ll_usart.c
  group Bsp
    ../../../Bsp/Src/: bsp_gpio.c bsp_uart1.c bsp_flash.c bsp_rcc.c
  group Middleware/common
    ../../../Middleware/common/param/: param.c
    ../../../Middleware/common/aip650e/: aip650e.c
    ../../../Middleware/common/timer_base/: timer_base.c
    ../../../Middleware/common/bootloader/: bootloader.c flash.c
    ../../../Middleware/common/port/: common_port.c
  group Middleware/protocol
    ../../../Middleware/protocol/: uart1_port.c
    ../../../Middleware/protocol/generic_protocol/: fan_protocol.c
  group Middleware/algorithm
    ../../../Middleware/algorithm/: crc.c
  group Application
    ../../../Application/: app_display.c app_boot.c
  group User
    ../Src/: main.c py32f032_it.c
  group Doc
    ../../../Doc/: 项目日志.md 芯片资源说明.md
    ../../../: README.md
software components: CMSIS:CORE 5.6.0
