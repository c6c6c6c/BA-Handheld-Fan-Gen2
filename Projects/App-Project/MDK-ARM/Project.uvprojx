# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F032x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.21
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ba_fan_app +hex
  AfterMake: fromelf --bincombined --output="..\..\Output\ba_fan_app.bin" ".\Output\ba_fan_app.axf"
  AfterMake: py -u "..\..\..\Tools\merge_bin\merge_bin.py" "..\..\..\Tools\merge_bin\merge_bin_config.json"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F032x8,USE_FULL_LL_DRIVER,APP_PROJECT,POWER_CTRL_GPIO
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\PY32F032\Include;..\..\..\Drivers\PY32F032_HAL_Driver\Inc;..\..\..\Bsp\Inc;..\..\..\Middleware\common\bootloader;..\..\..\Middleware\common\timer_base;..\..\..\Middleware\common\aip650e;..\..\..\Middleware\common\search;..\..\..\Middleware\common\param;..\..\..\Middleware\common\button;..\..\..\Middleware\common\sleep;..\..\..\Middleware\common\filter;..\..\..\Middleware\common\port;..\..\..\Middleware\common\fan;..\..\..\Middleware\common\ntc;..\..\..\Middleware\protocol;..\..\..\Middleware\mist_ctrl;..\..\..\Middleware\bms_ctrl;..\..\..\Middleware\protocol\generic_protocol;..\..\..\Middleware\data_structure;..\..\..\Middleware\algorithm;..\..\..\Application
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0xbe00
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./: startup_py32f032xx.s
    ../Src/: system_py32f032.c
  group Drivers/PY32F032_HAL_Driver
    ../../../Drivers/PY32F032_HAL_Driver/Src/: py32f032_ll_utils.c py32f032_ll_adc.c py32f032_ll_comp.c py32f032_ll_crc.c py32f032_ll_dma.c py32f032_ll_exti.c py32f032_ll_gpio.c py32f032_ll_i2c.c py32f032_ll_lptim.c py32f032_ll_lpuart.c py32f032_ll_pwr.c py32f032_ll_rcc.c py32f032_ll_rtc.c py32f032_ll_spi.c py32f032_ll_tim.c py32f032_ll_uart.c py32f032_ll_usart.c
  group Bsp
    ../../../Bsp/Src/: bsp_rcc.c bsp_adc.c bsp_wdg.c bsp_exti.c bsp_tim1.c bsp_tim3.c bsp_tim16.c bsp_gpio.c bsp_uart1.c bsp_pga2.c bsp_flash.c
  group Middleware/common
    ../../../Middleware/common/ntc/: ntc.c
    ../../../Middleware/common/fan/: fan.c
    ../../../Middleware/common/sleep/: sleep.c
    ../../../Middleware/common/filter/: filter.c
    ../../../Middleware/common/param/: param.c
    ../../../Middleware/common/button/: button.c
    ../../../Middleware/common/aip650e/: aip650e.c
    ../../../Middleware/common/timer_base/: timer_base.c
    ../../../Middleware/common/search/: binary_search.c
    ../../../Middleware/common/port/: common_port.c
  group Middleware/bms
    ../../../Middleware/bms_ctrl/: bms_soc.c bms_soh.c bms_key.c bms_status.c bms_convert.c
  group Middleware/mist
    ../../../Middleware/mist_ctrl/: mist_ctrl.c mist_process.c
  group Middleware/protocol
    ../../../Middleware/protocol/: uart1_port.c
    ../../../Middleware/protocol/generic_protocol/: fan_protocol.c
  group Middleware/algorithm
    ../../../Middleware/algorithm/: crc.c
  group Application
    ../../../Application/: app_mist.c app_bms.c app_logic.c app_system.c app_display.c app_sampling.c app_protect.c app_io_ctrl.c
  group User
    ../Src/: main.c py32f032_it.c
  group Doc
    ../../../Doc/: 项目日志.md 芯片资源说明.md
    ../../../: README.md
software components: CMSIS:CORE 5.6.0
